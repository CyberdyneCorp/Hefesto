.subckt inv A Y VDD VSS
.ends
