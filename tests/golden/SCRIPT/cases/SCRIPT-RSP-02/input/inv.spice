.subckt inv Y A VDD VSS
.ends
