.subckt reg D[0] D[1] CLK
.ends
