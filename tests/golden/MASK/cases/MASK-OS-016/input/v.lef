VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
VIA VX1 DEFAULT
  LAYER metal1 ;
    RECT -0.2 -0.2 0.2 0.2 ;
  LAYER via1 ;
    RECT -0.05 -0.05 0.05 0.05 ;
  LAYER metal2 ;
    RECT -0.2 -0.2 0.2 0.2 ;
END VX1
END LIBRARY
