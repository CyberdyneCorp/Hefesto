VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
MACRO argcell
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1 BY 2 ;
  OBS
      LAYER metal1 ;
        RECT 0 0 0.5 0.5 ;
  END
END argcell
END LIBRARY
