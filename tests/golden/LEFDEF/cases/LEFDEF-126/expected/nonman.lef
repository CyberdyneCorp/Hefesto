VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO nonman
  CLASS BLOCK ;
  FOREIGN nonman ;
  ORIGIN 0.000 -327.660 ;
  SIZE 0.000 BY -2.520 ;
  PIN A
    PORT
      LAYER metal1 ;
        POLYGON 0.000 0.300 0.100 0.300 0.100 0.200 ;
        POLYGON -0.100 0.100 0.000 0.000 -0.100 0.000 ;
        RECT 0.000 0.000 0.200 0.200 ;
        POLYGON 0.200 0.100 0.300 0.100 0.300 0.000 ;
        POLYGON 0.000 0.000 0.100 0.000 0.000 -0.100 ;
    END
  END A
  OBS
      LAYER metal1 ;
        POLYGON 0.600 0.700 0.700 0.700 0.700 0.600 ;
        POLYGON 0.800 0.700 0.900 0.700 0.800 0.600 ;
        POLYGON 1.100 0.700 1.100 0.600 1.000 0.600 ;
        POLYGON 1.200 0.700 1.300 0.600 1.200 0.600 ;
  END
END nonman
END LIBRARY

