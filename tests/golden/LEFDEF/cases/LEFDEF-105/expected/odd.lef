VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO odd
  CLASS BLOCK ;
  FOREIGN odd ;
  ORIGIN 0.000 -16.383 ;
  SIZE 0.000 BY -0.040 ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER metal1 ;
        RECT -0.002 -0.002 0.002 0.004 ;
    END
  END A
  OBS
      LAYER metal1 ;
        RECT 0.004 0.004 0.011 0.011 ;
  END
END odd
END LIBRARY

