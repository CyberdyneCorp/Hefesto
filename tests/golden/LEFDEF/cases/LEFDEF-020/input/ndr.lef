VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
VIA M1M2 DEFAULT
  LAYER metal1 ;
    RECT -0.04 -0.04 0.04 0.04 ;
  LAYER via1 ;
    RECT -0.02 -0.02 0.02 0.02 ;
  LAYER metal2 ;
    RECT -0.04 -0.04 0.04 0.04 ;
END M1M2
NONDEFAULTRULE W2
  HARDSPACING ;
  LAYER metal1
    WIDTH 0.06 ;
    SPACING 0.06 ;
    WIREEXTENSION 0.03 ;
  END metal1
VIA W2V12
  LAYER metal1 ;
    RECT -0.05 -0.05 0.05 0.05 ;
  LAYER via1 ;
    RECT -0.02 -0.02 0.02 0.02 ;
  LAYER metal2 ;
    RECT -0.05 -0.05 0.05 0.05 ;
END W2V12
  USEVIA M1M2 ;
  MINCUTS via1 2 ;
  PROPERTY weight 3 ;
END W2
NONDEFAULTRULE W2
  LAYER metal1
    WIDTH 0.1 ;
  END metal1
END W2
END LIBRARY
