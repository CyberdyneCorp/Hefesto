VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
PROPERTYDEFINITIONS
  MACRO MASK STRING ;
  MACRO CDL STRING ;
END PROPERTYDEFINITIONS

MACRO inv
  CLASS BLOCK ;
  FOREIGN inv ;
  ORIGIN 0.000 -327.670 ;
  SIZE 0.000 BY -1.270 ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER metal1 ;
        RECT 0.100 0.800 0.300 1.000 ;
    END
  END A
  PIN Y
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER metal1 ;
        RECT 0.700 0.800 0.900 1.000 ;
    END
  END Y
  OBS
      LAYER metal1 ;
        RECT 0.000 1.850 1.000 2.000 ;
        RECT 0.400 0.400 0.600 1.400 ;
        RECT 0.000 0.000 1.000 0.150 ;
  END
  PROPERTY CDL "inv x" ;
  PROPERTY MASK 1 ;
END inv
END LIBRARY

