VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO same
  CLASS BLOCK ;
  FOREIGN same ;
  ORIGIN 0.000 -327.650 ;
  SIZE 0.000 BY -0.350 ;
  PIN A
    PORT
      LAYER metal1 ;
        RECT 0.000 0.000 0.100 0.100 ;
    END
    PORT
      LAYER metal1 ;
        RECT 0.200 0.000 0.300 0.100 ;
    END
  END A
END same
END LIBRARY

