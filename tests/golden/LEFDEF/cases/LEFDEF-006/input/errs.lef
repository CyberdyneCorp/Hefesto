VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
MACRO errs
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1 BY 2 ;
  OBS
      LAYER nosuch0 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch1 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch2 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch3 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch4 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch5 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch6 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch7 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch8 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch9 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch10 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch11 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch12 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch13 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch14 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch15 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch16 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch17 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch18 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch19 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch20 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch21 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch22 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch23 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch24 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch25 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch26 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch27 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch28 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch29 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch30 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch31 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch32 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch33 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch34 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch35 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch36 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch37 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch38 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch39 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch40 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch41 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch42 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch43 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch44 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch45 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch46 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch47 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch48 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch49 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch50 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch51 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch52 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch53 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch54 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch55 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch56 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch57 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch58 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch59 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch60 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch61 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch62 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch63 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch64 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch65 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch66 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch67 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch68 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch69 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch70 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch71 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch72 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch73 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch74 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch75 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch76 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch77 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch78 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch79 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch80 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch81 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch82 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch83 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch84 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch85 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch86 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch87 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch88 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch89 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch90 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch91 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch92 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch93 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch94 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch95 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch96 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch97 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch98 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch99 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch100 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch101 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch102 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch103 ;
        RECT 0 0 0.1 0.1 ;
      LAYER nosuch104 ;
        RECT 0 0 0.1 0.1 ;
  END
END errs
END LIBRARY
