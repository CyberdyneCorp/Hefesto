VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO strip
  CLASS BLOCK ;
  FOREIGN strip ;
  ORIGIN 0.000 -327.650 ;
  SIZE 0.000 BY -2.120 ;
  PIN S
    PORT
      LAYER metal1 ;
        RECT 0.000 0.000 2.000 0.100 ;
    END
  END S
  PIN V
    PORT
      LAYER metal1 ;
        RECT 0.000 0.400 0.100 1.400 ;
    END
  END V
END strip
END LIBRARY

