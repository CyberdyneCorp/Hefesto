VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
VIA via_1_2
  LAYER metal1 ;
    RECT -0.03 -0.03 0.03 0.03 ;
  LAYER via1 ;
    RECT -0.02 -0.02 0.02 0.02 ;
  LAYER metal2 ;
    RECT -0.03 -0.03 0.03 0.03 ;
END via_1_2
END LIBRARY
