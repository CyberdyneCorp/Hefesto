VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO hide
  CLASS BLOCK ;
  FOREIGN hide ;
  ORIGIN 0.000 -327.670 ;
  SIZE 0.000 BY -0.390 ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER metal1 ;
        RECT 0.000 0.000 0.200 0.200 ;
    END
  END A
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
    PORT
      LAYER metal1 ;
        RECT 0.000 1.800 1.000 2.000 ;
    END
  END VDD
  OBS
      LAYER metal1 ;
        RECT 0.400 0.400 0.800 0.800 ;
      LAYER metal2 ;
        RECT 0.300 1.000 0.900 1.600 ;
  END
END hide
END LIBRARY

