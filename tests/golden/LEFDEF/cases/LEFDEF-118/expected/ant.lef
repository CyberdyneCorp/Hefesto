VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO ant
  CLASS BLOCK ;
  FOREIGN ant ;
  ORIGIN 0.000 -327.640 ;
  SIZE 0.000 BY -0.040 ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER POLY ;
        RECT 0.080 0.600 0.160 0.680 ;
        RECT 0.100 0.400 0.140 0.600 ;
      LAYER metal1 ;
        RECT 0.080 0.600 0.160 0.800 ;
    END
  END A
  PIN Y
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    ANTENNADIFFAREA 0.025600 ;
    PORT
      LAYER metal1 ;
        RECT 0.180 0.240 0.260 0.500 ;
    END
  END Y
  OBS
      LAYER POLY ;
        RECT 0.100 0.100 0.140 0.200 ;
  END
END ant
END LIBRARY

