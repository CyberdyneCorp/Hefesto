VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
SITE unit
  CLASS CORE ;
  SYMMETRY Y ;
  SIZE 0.2 BY 2 ;
END unit
END LIBRARY
