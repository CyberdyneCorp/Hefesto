v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {res.sym} 0 0 0 0 {name=R7 value=4.7k}
C {res.sym} 100 0 0 0 {name=X1 value=1}
C {res.sym} 200 0 0 0 {name=M1 W=2 L=1 value=2}
