** sch_path: tests/golden/SCHEM/cases/SCHEM-NL-14/input/nl14.sch
**.subckt nl14
x1 N1 N2 missing
x2 N1 N2 withdef
x3 N1 N2 stopped
x4 N1 N2 ignored
**.ends
.end
