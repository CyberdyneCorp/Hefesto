v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
L 4 20 0 10 5 {}
L 4 0 10 0 -10 {}
B 5 2.5 2.5 -2.5 -2.5 {name=A dir=in}
N 10.50 -20.0 30 -20 {}
T {line one
line two} 100 -50 0 0 0.4 0.4 {layer=4}
N 0 0 1e-5 0.30000000000000004 {}
