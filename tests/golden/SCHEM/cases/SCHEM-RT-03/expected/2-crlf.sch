v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 10 5 20 0 {}
L 4 0 -10 0 10 {}
B 5 -2.5 -2.5 2.5 2.5 {name=A dir=in}
T {line one
line two} 100 -50 0 0 0.4 0.4 {layer=4}
N 10.5 -20 30 -20 {}
N 0 0 1e-05 0.3 {}
