** sch_path: tests/golden/SCHEM/cases/SCHEM-PR-03/input/pr03.sch
**.subckt pr03
x1 N2 N3 N1 pinsort
x2 N1 N2 pinpart
**.ends
.end
