** sch_path: tests/golden/SCHEM/cases/SCHEM-PR-03/input/pinsort.sch
**.subckt pinsort A B C
*.iopin A
*.iopin B
*.iopin C
R1 A B 1k m=1
R2 B C 1k m=1
**.ends
.end
