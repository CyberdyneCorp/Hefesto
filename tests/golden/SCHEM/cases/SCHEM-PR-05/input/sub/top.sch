v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {../x.sym} 0 0 0 0 {name=x1}
C {lib/x.sym} 0 100 0 0 {name=x2}
