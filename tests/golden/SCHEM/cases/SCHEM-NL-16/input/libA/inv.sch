v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {iopin.sym} 0 0 0 0 {name=p1 lab=A}
C {iopin.sym} 0 100 0 0 {name=p2 lab=Y}
N 0 0 0 20 {}
N 0 80 0 100 {}
C {res.sym} 0 50 0 0 {name=R1 value=1k m=1}
