K {}
C {res} 0 0 0 0 {name=R1}
C {capa} 100 0 0 0 {name=C1}
