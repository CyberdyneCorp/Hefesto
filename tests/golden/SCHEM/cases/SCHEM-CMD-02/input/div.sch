** sch_path: tests/golden/SCHEM/cases/SCHEM-CMD-02/input/div.sch
**.subckt div
R1 IN net1 1k m=1
R2 net1 0 1k m=1
**.ends
.end
