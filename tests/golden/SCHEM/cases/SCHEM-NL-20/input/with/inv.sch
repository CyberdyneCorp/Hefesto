v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {opin.sym} 0 0 0 0 {name=p1 lab=Y}
C {ipin.sym} 0 100 0 0 {name=p2 lab=A}
N 0 0 0 20 {}
N 0 80 0 100 {}
C {res.sym} 0 50 0 0 {name=R1 value=1k}
