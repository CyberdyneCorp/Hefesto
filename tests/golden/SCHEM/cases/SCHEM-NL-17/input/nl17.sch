v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {netlist_options.sym} 300 -100 0 0 {name=o1 bus_replacement_char=<> top_is_subckt=true}
C {ipin.sym} 0 0 0 0 {name=p1 lab=IN[1:0]}
N 0 0 100 0 {}
C {res.sym} 100 30 0 0 {name=R1[1:0] value=1k}
C {opin.sym} 100 60 0 0 {name=p2 lab=OUT[1:0]}
