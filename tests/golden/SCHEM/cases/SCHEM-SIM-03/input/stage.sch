** sch_path: tests/golden/SCHEM/cases/SCHEM-SIM-03/input/stage.sch
**.subckt stage A Y
*.ipin A
*.opin Y
R1 A MID 1k m=1
R2 MID Y 1k m=1
**.ends
.end
