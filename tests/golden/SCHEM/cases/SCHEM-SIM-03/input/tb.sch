v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {stage.sym} 300 0 0 0 {name=x1}
N 200 0 260 0 {}
C {lab_pin.sym} 200 0 0 0 {name=l1 lab=IN}
N 200 20 260 20 {}
C {lab_pin.sym} 200 20 0 0 {name=l2 lab=OUT}
