v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
Z 1 2 {a
b} 3
# a comment record
N 0 0 10
N 0 10 20 10 {}
L 30 0 0 10 10 {}
L 4 0 0 10 10 {}
C {res.sym} 0 100 0 0 {name=R1 value=1k}
N 0 0 10 0 {lab=A
