v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 0 0 10 10 {}
N 0 0 10 0 {}
C {res.sym} 0 100 0 0 {name=R1 value=1k}
