.subckt top A VDD!
.ends
