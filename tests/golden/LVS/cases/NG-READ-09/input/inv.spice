* inv
.subckt inv Y A
R1 A Y 1k
.ends
