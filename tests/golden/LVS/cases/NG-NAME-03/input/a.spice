* a
.subckt top nét1 b
R1 nét1 b 1k
.ends
