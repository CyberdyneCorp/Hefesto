* empty
.subckt emptyc a b
.ends
